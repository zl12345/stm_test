# Keil uVision project SF6_SixChannel.uvprojx, settings and files
target SF6_SixChannel (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SF6_SixChannel
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;.\ADDRESS;.\MEASURE;.\freemodbus\modbus\include;.\freemodbus\GeneralTIM;.\freemodbus\RS485;.\freemodbus\modbus\rtu;.\freemodbus\modbus\ascii;.\MEMORY;.\STMFLASH;.\freemodbus;.\MODBUS_MASTER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group modbus
    ./freemodbus/modbus/: mb.c
    ./freemodbus/modbus/ascii/: mbascii.c
    ./freemodbus/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./freemodbus/modbus/tcp/: mbtcp.c
  group port
    ./freemodbus/: portdata.c portevent.c portserial.c porttimer.c
    ./freemodbus/GeneralTIM/: bsp_GeneralTIM.c
    ./freemodbus/RS485/: bsp_usartx_RS485.c
  group stmflash
    ./STMFLASH/: stmflash.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_iwdg.c
  group Application/User
    ../Src/: stm32f1xx_it.c gpio.c main.c usart.c tim.c stm32f1xx_hal_msp.c iwdg.c
    ./ADDRESS/: address.c
    ./MEASURE/: measure.c
    ./MEMORY/: memory.c
    ./MODBUS_MASTER/: modbus.c
software components: CMSIS:CORE 4.3.0
